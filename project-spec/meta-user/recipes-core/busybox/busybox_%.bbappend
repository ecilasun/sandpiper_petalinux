FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://login_timeout.cfg \
            file://user_2026-01-31-22-20-00.cfg \
            file://user_2026-01-31-22-28-00.cfg \
            "
